# IAR project tinyusb_cdc_dual_ports.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; apollo4b_evb; AM_PART_APOLLO4B; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\..\..\devices; ..\src; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_dual_ports.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_dual_ports.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; apollo4b_evb; AM_PART_APOLLO4B; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=2
  group (top)
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_dual_ports.c usb_descriptors.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
