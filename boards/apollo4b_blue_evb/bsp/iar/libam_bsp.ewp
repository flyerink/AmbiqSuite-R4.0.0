# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; DISP_CFG; DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X12; DISP_TYPE=RM67162_DSI; AM_PACKAGE_BGA; NUM_LANES=1; AM_PART_APOLLO4B; B_USE_DPHYPLL=true; DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_8
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\apollo4b; ..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\utils; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c am_bsp_pins.c
