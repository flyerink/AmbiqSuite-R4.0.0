# IAR project tinyusb_hid_generic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; CFG_TUSB_DEBUG=2; apollo4b_blue_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\..\..\third_party\tinyusb\src\class\hid; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\src\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_hid_generic.bin
  ILINK.IlinkOutputFile: tinyusb_hid_generic.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; CFG_TUSB_DEBUG=2; apollo4b_blue_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../src/: am_resources.c apollo4_board.c tinyusb_hid_generic.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/src/class/hid/: hid_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
