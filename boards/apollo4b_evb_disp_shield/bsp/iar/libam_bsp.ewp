# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_16; NUM_LANES=1; DISP_TYPE=RM69330_DSI; AM_PART_APOLLO4B; DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X20; B_USE_DPHYPLL=false; AM_PACKAGE_BGA; DISP_CFG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\mcu\apollo4b; ..\..\..\..\devices; ..\..\..\..\utils; ..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c am_bsp_pins.c
