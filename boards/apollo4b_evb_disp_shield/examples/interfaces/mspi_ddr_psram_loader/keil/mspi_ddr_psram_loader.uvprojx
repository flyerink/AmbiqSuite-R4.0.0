# Keil uVision project mspi_ddr_psram_loader.uvprojx, settings and files
target mspi_ddr_psram_loader (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_ddr_psram_loader
  AfterMake: fromelf --bin --output bin\mspi_ddr_psram_loader.bin bin\mspi_ddr_psram_loader.axf
  AfterMake: fromelf -cedrst --output bin\mspi_ddr_psram_loader.txt bin\mspi_ddr_psram_loader.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APS12808L AM_PART_APOLLO4B AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA keil
  c include: ../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../src;../../../../../../CMSIS/ARM/Include;../../../../bsp;../../../../../../mcu/apollo4b;../../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c mspi_ddr_psram_loader.c
  group devices
    ../../../../../../devices/: am_devices_mspi_psram_aps12808l.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
