# IAR project nemagfx_watch_gui.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; AM_PACKAGE_BGA; AM_PART_APOLLO4B; PLATFORM=apollo4b_nemagfx; AM_FREERTOS; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo4; ..\src\generated; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\src\generated\assets\images; ..\src\generated\NemaGUI; ..\src\generated\assets\fonts; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_watch_gui.bin
  ILINK.IlinkOutputFile: nemagfx_watch_gui.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_TSI_MALLOC; AM_PACKAGE_BGA; AM_PART_APOLLO4B; PLATFORM=apollo4b_nemagfx; AM_FREERTOS; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib
  group (top)
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../src/: am_resources.c gui_task.c nemagfx_watch_gui.c rtos.c
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../src/generated/NemaGUI/: main.c
    ./: startup_iar.c
