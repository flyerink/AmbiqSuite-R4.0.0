# Keil uVision project nemagfx_nemagui_ambiq_logo.uvprojx, settings and files
target nemagfx_nemagui_ambiq_logo (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_nemagui_ambiq_logo
  AfterMake: fromelf --bin --output bin\nemagfx_nemagui_ambiq_logo.bin bin\nemagfx_nemagui_ambiq_logo.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_nemagui_ambiq_logo.txt bin\nemagfx_nemagui_ambiq_logo.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA USE_TOUCH NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK PLATFORM=apollo4b_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_FREERTOS AM_PART_APOLLO4B USE_TSI_MALLOC keil
  c include: ../src/generated/assets/fonts;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../src;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../src/generated;../../../../../../mcu/apollo4b;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../..;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4;../src/generated/NemaGUI/gitems;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../src/generated/NemaGUI;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../src/generated/assets/images;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group gitems
    ../src/generated/NemaGUI/gitems/: ng_button.c ng_checkbox.c ng_circle.c ng_circular_progress.c ng_container.c ng_digimeter.c ng_gauge.c ng_gitem_template.c ng_icon.c ng_image.c ng_label.c ng_needle.c ng_progress_bar.c ng_radio_button.c ng_rect.c ng_rounded_rect.c ng_screen.c ng_slider.c ng_slider_hor.c ng_slider_ver.c ng_watchface.c ng_window.c
  group NemaGUI
    ../src/generated/NemaGUI/: ng_animation.c ng_callbacks.c ng_display.c ng_draw.c ng_draw_prim.c ng_event.c ng_event_oneshot.c ng_event_periodic.c ng_event_periodic_transition.c ng_event_transition.c ng_gestures.c ng_gitem.c ng_globals.c ng_main.c ng_screen_trans.c ng_timer.c ng_tree.c ng_utils.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_nemagui_ambiq_logo.c rtos.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group FreeRTOSv10.1.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo4/: port.c
  group generated
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c screen_groups.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c am_devices_tma525.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
