# IAR project nemagfx_nemagui_ambiq_logo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; USE_TOUCH; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; AM_PART_APOLLO4B; USE_TSI_MALLOC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src\generated\assets\fonts; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo4; ..\src; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\src\generated; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\src\generated\NemaGUI\gitems; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\src\generated\NemaGUI; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\src\generated\assets\images; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_nemagui_ambiq_logo.bin
  ILINK.IlinkOutputFile: nemagfx_nemagui_ambiq_logo.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; USE_TOUCH; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; PLATFORM=apollo4b_nemagfx; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; AM_PART_APOLLO4B; USE_TSI_MALLOC
  group (top)
    ../src/generated/NemaGUI/gitems/: ng_button.c ng_checkbox.c ng_circle.c ng_circular_progress.c ng_container.c ng_digimeter.c ng_gauge.c ng_gitem_template.c ng_icon.c ng_image.c ng_label.c ng_needle.c ng_progress_bar.c ng_radio_button.c ng_rect.c ng_rounded_rect.c ng_screen.c ng_slider.c ng_slider_hor.c ng_slider_ver.c ng_watchface.c ng_window.c
    ../src/generated/NemaGUI/: ng_animation.c ng_callbacks.c ng_display.c ng_draw.c ng_draw_prim.c ng_event.c ng_event_oneshot.c ng_event_periodic.c ng_event_periodic_transition.c ng_event_transition.c ng_gestures.c ng_gitem.c ng_globals.c ng_main.c ng_screen_trans.c ng_timer.c ng_tree.c ng_utils.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../src/: am_resources.c gui_task.c nemagfx_nemagui_ambiq_logo.c rtos.c
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c screen_groups.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c am_devices_tma525.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./: startup_iar.c
