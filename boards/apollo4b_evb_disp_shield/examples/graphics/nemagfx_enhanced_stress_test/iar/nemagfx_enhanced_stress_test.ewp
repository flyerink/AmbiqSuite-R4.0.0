# IAR project nemagfx_enhanced_stress_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; THDEBUG=0; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4; MITH_MEMORY_ONLY_VERSION=1; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; PLATFORM=apollo4b_nemagfx; REPORT_THMALLOC_STATS=0; AM_UTIL_FAULTISR_PRINT; USE_TSI_MALLOC; AM_PART_APOLLO4B; AM_FREERTOS; apollo4b_evb_disp_shield; CC_IOT; BMDEBUG=0; VERBOSE=1; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src\coremark_pro\FreeRTOS_Plus_POSIX\include\private; ..\src\crypto; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\src\coremark_pro\FreeRTOS_Plus_POSIX\FreeRTOS-Plus-POSIX\include; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\third_party\tinyusb\src\class\msc; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\src\coremark_pro\FreeRTOS_Plus_POSIX\include\FreeRTOS_POSIX; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src\coremark_pro\FreeRTOS_Plus_POSIX\include; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\tinyusb\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\src\coremark_pro\benchmarks\fp\loops; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\src\coremark_pro\mith\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\src\coremark_pro\mith\al\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_enhanced_stress_test.bin
  ILINK.IlinkOutputFile: nemagfx_enhanced_stress_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; THDEBUG=0; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4; MITH_MEMORY_ONLY_VERSION=1; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; PLATFORM=apollo4b_nemagfx; REPORT_THMALLOC_STATS=0; AM_UTIL_FAULTISR_PRINT; USE_TSI_MALLOC; AM_PART_APOLLO4B; AM_FREERTOS; apollo4b_evb_disp_shield; CC_IOT; BMDEBUG=0; VERBOSE=1; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK
  group (top)
    ../src/coremark_pro/workloads/loops-all-mid-10k-sp/: loops-all-mid-10k-sp.c
    ../src/coremark_pro/mith/src/: md5.c mith_lib.c mith_workload.c th_bignum.c th_encode.c th_getopt.c th_lib.c th_math.c th_rand.c
    ../src/coremark_pro/FreeRTOS_Plus_POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: adc_task.c am_resources.c apollo4_board.c crypto_task.c display_task.c emmc_task.c graphics_power_control.c gui_task.c heap_4_external.c hp_lp_task.c iom_psram_task.c msc_disk.c mspi_task.c nemagfx_enhanced_stress_test.c psram.c render_task.c rtos.c tinyusb_cdc_msc_freertos.c usb_descriptors.c xip_task.c
    ../src/crypto/: crc_task.c crypto_operations.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../src/coremark_pro/mith/al/src/: al_file.c al_single.c al_smp.c th_al.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../src/coremark_pro/benchmarks/fp/loops/: loops.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_mspi_atxp032.c am_devices_nemadc_rm67162.c am_devices_spipsram.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../src/coremark_pro/benchmarks/fp/loops/ref-sp/: 100.c 100k.c 100kdot.c 10k.c 10kdot.c 1k.c 1kdot.c 32.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../third_party/tinyusb/src/class/msc/: msc_device.c
    ./: startup_iar.c
