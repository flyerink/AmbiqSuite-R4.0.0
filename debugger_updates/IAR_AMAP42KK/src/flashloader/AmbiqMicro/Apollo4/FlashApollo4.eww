<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FlashApollo4.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>FlashApollo4</project>
        <configuration>FlashApollo4_2048</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


